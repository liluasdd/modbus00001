# Keil uVision project stm32f103.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\uart1;..\..\Drivers\BSP\led;..\..\STM32MB\STM32MB\modbus\rtu;..\..\STM32MB\STM32MB\port;..\..\STM32MB\STM32MB\modbus\include;..\..\software\inc;..\..\software\mb_user;..\..\software\app_tft_lcd;..\..\Free_ROTS_2024\port;..\..\Free_ROTS_2024\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f101xb.s
  group User
    ../../Users/: main.c stm32f1xx_it.c main.h usertype.h
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Free_ROTS_2024/inc/: FreeRTOSConfig.h
  group Modbus/RTU
    ../../STM32MB/STM32MB/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../../STM32MB/STM32MB/modbus/: mb.c
  group Modbus/port
    ../../STM32MB/STM32MB/port/: port.h portevent.c portserial.c porttimer.c
  group usart/app
    ../../software/mb_user/: user_mb_app.c user_mb_app.h
  group Modbus
    ../../STM32MB/STM32MB/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group software
    ../../software/src/: adc.c gpio.c key.c tim.c uart.c usart.c oled.c led.c sys_monitor.c
    ../../software/inc/: adc.h usart.h gpio.h key.h tim.h
    ../../software/app_src/: APP_modbus.c
  group app_lcd
    ../../software/app_tft_lcd/: ctiic.c ctiic.h ctp.c ctp.h font.H lcd.c lcd.h test code.c test code.h touch.c touch.h font.c
  group FreeRTOS_test
    ../../software/app_FreeRTOS/: freertos_test.c
  group FreeRTOS_2024/port
    ../../Free_ROTS_2024/port/: heap_4.c port.c portmacro.h
  group FreeRTOS_2024/src
    ../../Free_ROTS_2024/src/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c freertos_hooks.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
