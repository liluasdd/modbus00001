#include "oled.h"

void u16_to_4digits(char *s, uint16_t v, uint8_t dot)
{
    if (v > 9999)
        v = 9999; // ǯλ����ֹ�����ʾ
    // // s[0] = '0' + (v / 1000) % 10;
    // s[0] = '0' + (v / 1000);
    // s[1] = '0' + (v / 100) % 10;
    // s[2] = '0' + (v / 10) % 10;
    // s[3] = '0' + v % 10;
    // s[4] = '\0';

    if (dot == 1)
    {
        s[0] = '0' + (v / 100) % 10;
        s[1] = '.';
        s[2] = '0' + (v / 10) % 10;
        s[3] = '0' + v % 10;
        // s[4] = '\0';
        s[4] = 'V';
        s[5] = '\0';
    }
    else if (dot == 2)
    {
        s[0] = '0' + (v / 100) % 10;
        s[1] = '0' + (v / 10) % 10;
        s[2] = '.';
        s[3] = '0' + v % 10;
        // s[4] = '\0';
        s[4] = 'V';
        s[5] = '\0';
    }
    else
    {
        s[0] = '0' + (v / 1000);
        s[1] = '0' + (v / 100) % 10;
        s[2] = '0' + (v / 10) % 10;
        s[3] = '0' + v % 10;
        s[4] = '\0';
    }
}
